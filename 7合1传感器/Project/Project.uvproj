# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\App
  group User
    ../User/: main.c
  group App
    ../App/: RI2C.c delay.c uart1.c adc.c timer2.c digital_cube.c addr.c uart2.c ModeBusRTU.c timer0.c
  group Doc
    ../Doc/: Note.txt
